* /home/notartyom/Desktop/Projects/BBlitz/Rev.A/BBlitz.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Fri 02 Mar 2018 10:11:38 AM EST

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U6  ? A0 /A30 ? ? /A24 /A23 /A21 /A19 /A17 /A15 /A13 /A10 ? ? /A31 /A29 ? ? /A22 /A20 /A16 /A14 /A12 /A8 /A7 FC1 ? ? A1 +5V +5V +5V /A18 +5V /A11 /A9 /A5 /A4 FC2 FC0 ? +5V +5V /A6 /A3 /A2 CLK Net-_U33-Pad16_ +5V +5V Net-_U33-Pad15_ DSACK0 +5V +5V +5V RESET STERM DSACK1 +5V +5V Net-_R1-Pad2_ Net-_R2-Pad2_ ? Net-_U35-Pad3_ +5V +5V +5V Net-_R3-Pad2_ +5V AS +5V +5V ? ? ? DS SIZ1 +5V +5V /D5 /D1 /D0 +5V SIZ0 R/W /D30 +5V +5V +5V +5V +5V /D10 /D7 /D4 /D2 ? ECS /D29 /D27 /D24 /D22 /D20 /D17 /D14 /D12 /D9 /D6 /D3 /D31 /D28 /D26 /D25 /D23 /D21 /D19 /D18 /D16 /D15 /D13 /D11 /D8 M68030
Y1  ? +5V Net-_JP1-Pad1_ +5V 25MHz
JP1  Net-_JP1-Pad1_ CLK JUMPER
P1  CLK CLK_EXT
J1  ? /ID7 /ID6 /ID5 /ID4 /ID3 /ID2 /ID1 /ID0 ? +5V /IA19 /IA18 /IA17 /IA16 /IA15 /IA14 /IA13 /IA12 /IA11 /IA10 /IA9 /IA8 /IA7 /IA6 /IA5 /IA4 /IA3 /IA2 /IA1 /IA0 +5V 8080_RESET +5V ? ? ? -12V NOWS +12V +5V MEMWR MEMRD IOWR IORD ? ? ? ? ? 8MHz ? ? ISA_IRQ5 ISA_IRQ4 ISA_IRQ3 ? ? ALE +5V 14MHz +5V Net-_J1-PadC1_ /IA23 /IA22 /IA21 /IA20 /IA19 /IA18 /IA17 MEMRD MEMWR /ID8 /ID9 /ID10 /ID11 /ID12 /ID13 /ID14 /ID15 MEMCS19 IOCS19 ? ? ? ? ? ? ? ? ? ? ? ? ? +5V ? +5V ISAx16
U26  RD0 /D0 /D1 /D2 /D3 /D4 /D5 /D6 /D7 +5V /ID7 /ID6 /ID5 /ID4 /ID3 /ID2 /ID1 /ID0 ISACE +5V 74LS245
U27  RD1 /D8 /D9 /D10 /D11 /D12 /D13 /D14 /D15 +5V /ID15 /ID14 /ID13 /ID12 /ID11 /ID10 /ID9 /ID8 ISACE +5V 74LS245
U28  _R/W A0 A1 /A2 /A3 /A4 /A5 /A6 /A7 +5V /IA7 /IA6 /IA5 /IA4 /IA3 /IA2 /IA1 /IA0 ISACE +5V 74LS245
U29  _R/W /A8 /A9 /A10 /A11 /A12 /A13 /A14 /A15 +5V /IA15 /IA14 /IA13 /IA12 /IA11 /IA10 /IA9 /IA8 ISACE +5V 74LS245
U30  _R/W /A16 /A17 /A18 /A19 /A20 /A21 /A22 /A23 +5V /IA23 /IA22 /IA21 /IA20 /IA19 /IA18 /IA17 /IA16 ISACE +5V 74LS245
Y2  ? +5V 14MHz +5V 14.31818MHz
U1  R/W _R/W Net-_U1-Pad3_ UART_IRQ RESET 8080_RESET +5V Net-_U1-Pad8_ 8MHz Net-_U1-Pad10_ DTACK Net-_U1-Pad12_ NOWS +5V 74LS04
U16  /A18 /A16 /A15 /A12 /A7 /A6 /A5 /A4 /A3 /A2 A1 A0 /D0 /D1 /D2 +5V /D3 /D4 /D5 /D6 /D7 BIOS /A10 _R/W /A11 /A9 /A8 /A13 /A14 /A17 ? +5V SST39SF040
U17  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D0 /D1 /D2 +5V /D3 /D4 /D5 /D6 /D7 RAM0 /A12 RD0 /A13 /A11 /A10 /A15 WR0 /A19 /A17 +5V AS6C4008
U14  Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_C2-Pad1_ +5V RESET +5V +5V Net-_C3-Pad1_ SYS_INT +5V Net-_C2-Pad1_ Net-_C3-Pad1_ Net-_R5-Pad2_ +5V 556
R4  +5V Net-_C1-Pad1_ 10k
C2  Net-_C2-Pad1_ +5V 100nf
C1  Net-_C1-Pad1_ +5V 100nf
R5  +5V Net-_R5-Pad2_ 10k
R6  Net-_R5-Pad2_ Net-_C3-Pad1_ 10k
C3  Net-_C3-Pad1_ +5V .47uf
R1  +5V Net-_R1-Pad2_ 10k
R2  +5V Net-_R2-Pad2_ 10k
R3  +5V Net-_R3-Pad2_ 10k
U25  /D2 /D1 /D0 ? +5V +5V +5V +5V +5V +5V CLK +5V +5V +5V +5V +5V +5V DS AS /A4 /A3 /A2 A1 +5V +5V R/W FPU +5V DSACK0 DSACK1 /D31 /D30 /D29 /D28 /D27 /D26 /D25 /D24 +5V /D23 +5V /D22 /D21 /D20 /D19 /D18 /D17 /D16 +5V +5V +5V /D15 /D14 /D13 /D12 /D11 /D10 /D9 +5V /D8 +5V /D7 /D6 /D5 /D4 /D3 M68882_PLCC
U2  /A19 /A20 /A21 Net-_U2-Pad4_ /A24 +5V ? +5V ? ? ? MSE KBD UART BIOS +5V 74LS138
U4  /A29 /A30 /A31 Net-_U4-Pad4_ Net-_U4-Pad4_ +5V ? +5V ? ? IDE1 IDE0 ISAIO ISAMEM Net-_U2-Pad4_ +5V 74LS138
U18  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D8 /D9 /D10 +5V /D11 /D12 /D13 /D14 /D15 RAM0 /A12 RD1 /A13 /A11 /A10 /A15 WR1 /A19 /A17 +5V AS6C4008
U19  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D16 /D17 /D18 +5V /D19 /D20 /D21 /D22 /D23 RAM0 /A12 RD2 /A13 /A11 /A10 /A15 WR2 /A19 /A17 +5V AS6C4008
U20  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D24 /D25 /D26 +5V /D27 /D28 /D29 /D30 /D31 RAM0 /A12 RD3 /A13 /A11 /A10 /A15 WR3 /A19 /A17 +5V AS6C4008
U3  /A21 /A22 /A23 +5V Net-_U2-Pad4_ /A24 ? +5V ? ? FPU RAM3 RAM2 RAM1 RAM0 +5V 74LS138
U5  ? A0 A1 SIZ0 SIZ1 AS DS ECS ? +5V ? WR0 WR1 WR2 WR3 RD0 RD1 RD2 RD3 +5V ATF16V8
U7  /D0 /D1 /D2 /D3 /D4 /D5 /D6 /D7 Net-_U7-Pad15_ RXD Net-_U10-Pad10_ +5V +5V UART Net-_U7-Pad15_ 14MHz ? +5V 8080_WR +5V +5V 8080_RD ? ? ? /A3 /A2 A1 Net-_U1-Pad3_ ? Net-_U10-Pad4_ Net-_U10-Pad2_ ? 8080_RESET CTS DSR DCD +5V +5V 8250
J2  Net-_J2-Pad1_ Net-_J2-Pad2_ Net-_J2-Pad3_ Net-_J2-Pad4_ +5V Net-_J2-Pad6_ Net-_J2-Pad7_ Net-_J2-Pad8_ ? DB9
U10  -12V Net-_U10-Pad2_ Net-_J2-Pad4_ Net-_U10-Pad4_ Net-_U10-Pad4_ Net-_J2-Pad7_ +5V Net-_J2-Pad3_ Net-_U10-Pad10_ Net-_U10-Pad10_ ? ? ? +12V DS1488
U8  Net-_J2-Pad2_ +5V RXD Net-_J2-Pad6_ +5V DSR +5V CTS +5V Net-_J2-Pad8_ DCD +5V Net-_J2-Pad1_ +5V DS1489
U9  ? +5V ? ? ? ? +5V ? ? ? ? ? ? +5V DS1489
U12  R/W Net-_U11-Pad10_ R/W Net-_U12-Pad4_ R/W Net-_U12-Pad6_ +5V +5V 74HC04
U11  ISAMEM ISAIO ISEL +5V R/W 8080_WR +5V 8080_RD +5V Net-_U11-Pad10_ +5V 7400
U32  ISEL _ISEL AS Net-_U31-Pad5_ +5V +5V 74LS04
U31  ISEL Net-_U31-Pad5_ ALE +5V +5V 7400
U13  ISAMEM R/W MEMWR ISAIO R/W IOWR +5V Net-_U13-Pad12_ Net-_U1-Pad12_ Net-_U13-Pad10_ DTACK Net-_U13-Pad12_ _ISEL +5V 74LS32
U15  Net-_U1-Pad10_ Net-_U1-Pad8_ ? ? ? ? ? +5V ? ISEL ? Net-_U13-Pad10_ ? ? ? +5V 74LS161
D1  Net-_D1-Pad1_ +5V LED
R8  +5V Net-_D1-Pad1_ 1k
U34  ? /A24 Net-_U2-Pad4_ ISAMEM ISAIO 14MHz MEMCS19 IOCS19 ? +5V ? DSACK0 DSACK1 STERM DTACK ? ? 8MHz ISACE +5V ATF16V8
U33  CLK SYS_INT UART_IRQ IDE_IRQ KBD_IRQ ISA_IRQ3 ISA_IRQ4 ISA_IRQ5 ? +5V ? Net-_R1-Pad2_ Net-_R2-Pad2_ Net-_R3-Pad2_ Net-_U33-Pad15_ Net-_U33-Pad16_ FC0 FC1 FC2 +5V ATF16V8
U35  +5V RESET Net-_U35-Pad3_ Net-_U12-Pad4_ ISAMEM MEMRD +5V IORD Net-_U12-Pad6_ ISAIO +5V 74LS32
U22  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D16 /D17 /D18 +5V /D19 /D20 /D21 /D22 /D23 RAM1 /A12 RD2 /A13 /A11 /A10 /A15 WR2 /A19 /A17 +5V AS6C4008
U24  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D24 /D25 /D26 +5V /D27 /D28 /D29 /D30 /D31 RAM1 /A12 RD3 /A13 /A11 /A10 /A15 WR3 /A19 /A17 +5V AS6C4008
U21  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D0 /D1 /D2 +5V /D3 /D4 /D5 /D6 /D7 RAM1 /A12 RD0 /A13 /A11 /A10 /A15 WR0 /A19 /A17 +5V AS6C4008
U23  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D8 /D9 /D10 +5V /D11 /D12 /D13 /D14 /D15 RAM1 /A12 RD1 /A13 /A11 /A10 /A15 WR1 /A19 /A17 +5V AS6C4008
U36  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D0 /D1 /D2 +5V /D3 /D4 /D5 /D6 /D7 RAM2 /A12 RD0 /A13 /A11 /A10 /A15 WR0 /A19 /A17 +5V AS6C4008
U40  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D8 /D9 /D10 +5V /D11 /D12 /D13 /D14 /D15 RAM2 /A12 RD1 /A13 /A11 /A10 /A15 WR1 /A19 /A17 +5V AS6C4008
U37  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D16 /D17 /D18 +5V /D19 /D20 /D21 /D22 /D23 RAM2 /A12 RD2 /A13 /A11 /A10 /A15 WR2 /A19 /A17 +5V AS6C4008
U41  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D24 /D25 /D26 +5V /D27 /D28 /D29 /D30 /D31 RAM2 /A12 RD3 /A13 /A11 /A10 /A15 WR3 /A19 /A17 +5V AS6C4008
U39  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D16 /D17 /D18 +5V /D19 /D20 /D21 /D22 /D23 RAM3 /A12 RD2 /A13 /A11 /A10 /A15 WR2 /A19 /A17 +5V AS6C4008
U43  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D24 /D25 /D26 +5V /D27 /D28 /D29 /D30 /D31 RAM3 /A12 RD3 /A13 /A11 /A10 /A15 WR3 /A19 /A17 +5V AS6C4008
U38  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D0 /D1 /D2 +5V /D3 /D4 /D5 /D6 /D7 RAM3 /A12 RD0 /A13 /A11 /A10 /A15 WR0 /A19 /A17 +5V AS6C4008
U42  /A20 /A18 /A16 /A14 /A9 /A8 /A7 /A6 /A5 /A4 /A3 /A2 /D8 /D9 /D10 +5V /D11 /D12 /D13 /D14 /D15 RAM3 /A12 RD1 /A13 /A11 /A10 /A15 WR1 /A19 /A17 +5V AS6C4008
P2  RESET +5V /D0 /D8 /D1 /D9 /D2 /D10 /D3 /D11 /D4 /D12 /D5 /D13 /D6 /D14 /D7 /D15 +5V ? ? +5V 8080_WR +5V 8080_RD +5V ? ? +5V +5V IDE_IRQ ? A1 ? A0 /A2 IDE0 IDE1 Net-_D2-Pad1_ +5V CONN_02X20
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ ACTIVE
R12  Net-_D2-Pad2_ +5V 1k
U48  Net-_U47-Pad6_ Net-_U45-Pad12_ KBD_IRQ Net-_U47-Pad11_ Net-_U47-Pad13_ Net-_U46-Pad12_ +5V +5V 74LS32
J4  Net-_J4-Pad1_ +5V +5V Net-_J4-Pad5_ PS/2 Mouse
U49  /D1 /D2 /D3 /D4 /D5 /D6 /D7 +5V ? ? Net-_U44-Pad4_ Net-_U47-Pad13_ MSE Net-_J4-Pad1_ /D0 +5V 74HC595
U44  Net-_J3-Pad5_ Net-_U44-Pad2_ Net-_J4-Pad5_ Net-_U44-Pad4_ WR1 Net-_J1-PadC1_ +5V +5V 74LS04
U46  Net-_U44-Pad2_ KBD_IRQ Net-_U46-Pad3_ Net-_U46-Pad4_ ? Net-_U46-Pad6_ +5V Net-_U46-Pad8_ ? Net-_U46-Pad10_ Net-_U46-Pad11_ Net-_U46-Pad12_ Net-_U44-Pad4_ +5V 74LS393
U47  Net-_U46-Pad3_ Net-_U46-Pad6_ Net-_U45-Pad12_ Net-_U46-Pad4_ Net-_U45-Pad12_ Net-_U47-Pad6_ +5V Net-_U47-Pad13_ Net-_U46-Pad11_ Net-_U46-Pad8_ Net-_U47-Pad11_ Net-_U46-Pad10_ Net-_U47-Pad13_ +5V 74LS08
J3  Net-_J3-Pad1_ +5V +5V Net-_J3-Pad5_ PS/2 Keyboard
U45  /D1 /D2 /D3 /D4 /D5 /D6 /D7 +5V ? ? Net-_U44-Pad2_ Net-_U45-Pad12_ KBD Net-_J3-Pad1_ /D0 +5V 74HC595
R10  +5V Net-_J4-Pad1_ 1k
R11  +5V Net-_J4-Pad5_ 1k
R7  +5V Net-_J3-Pad1_ 1k
R9  +5V Net-_J3-Pad5_ 1k

.end
